# Keil uVision project STM32F411CEU6.uvprojx, settings and files
target STM32F411CEU6 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32F411CEU6 +hex
  AfterMake: $K\ARM\ARM_Compiler_5.06u7\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE,LWRB_DISABLE_ATOMIC,USER_VECT_TAB_ADDRESS
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Adapter/Inc;../BSP/Inc;../APP/Inc;../Third_Part/lwrb/lwrb/src/include/lwrb
  memory RVCT4: ROM 0x800c000 size 0x34000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c iwdg.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_iwdg.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Adapter
    ../Adapter/Src/: app_adapter_led.c app_adapter_key.c app_adapter_flash.c app_adapter_w25qxx.c app_adapter_uart.c app_adapter_iwdg.c
  group BSP
    ../BSP/Src/: bsp_driver_led.c bsp_driver_key.c bsp_driver_flash.c bsp_driver_uart.c bsp_driver_iwdg.c
  group APP
    ../APP/Src/: app_updata.c app_ymodel.c
  group Third
    ../Third_Part/lwrb/lwrb/src/lwrb/: lwrb.c lwrb_ex.c
software components: CMSIS:CORE 4.3.0
